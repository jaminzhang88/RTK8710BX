<?xml version="1.0" encoding="UTF-8"?>
<project>
    <fileVersion>3</fileVersion>
    <configuration>
        <name>Debug</name>
        <toolchain>
            <name>ARM</name>
        </toolchain>
        <debug>1</debug>
        <settings>
            <name>C-STAT</name>
            <archiveVersion>261</archiveVersion>
            <data>
                <version>261</version>
                <cstatargs>
                    <useExtraArgs>0</useExtraArgs>
                    <extraArgs></extraArgs>
                    <analyzeTimeoutEnabled>1</analyzeTimeoutEnabled>
                    <analyzeTimeout>600</analyzeTimeout>
                    <enableParallel>0</enableParallel>
                    <parallelThreads>1</parallelThreads>
                    <enableFalsePositives>0</enableFalsePositives>
                    <messagesLimitEnabled>1</messagesLimitEnabled>
                    <messagesLimit>100</messagesLimit>
                </cstatargs>
                <cstat_settings>
                    <cstat_version>1.5.2</cstat_version>
                    <checks_tree>
                        <package name="STDCHECKS" enabled="true">
                            <group enabled="true" name="ARR">
                                <check name="ARR-inv-index-pos" enabled="true" />
                                <check name="ARR-inv-index-ptr-pos" enabled="true" />
                                <check name="ARR-inv-index-ptr" enabled="true" />
                                <check name="ARR-inv-index" enabled="true" />
                                <check name="ARR-neg-index" enabled="true" />
                                <check name="ARR-uninit-index" enabled="true" />
                            </group>
                            <group enabled="true" name="ATH">
                                <check name="ATH-cmp-float" enabled="true" />
                                <check name="ATH-cmp-unsign-neg" enabled="true" />
                                <check name="ATH-cmp-unsign-pos" enabled="true" />
                                <check name="ATH-div-0-assign" enabled="true" />
                                <check name="ATH-div-0-cmp-aft" enabled="false" />
                                <check name="ATH-div-0-cmp-bef" enabled="true" />
                                <check name="ATH-div-0-interval" enabled="true" />
                                <check name="ATH-div-0-pos" enabled="true" />
                                <check name="ATH-div-0-unchk-global" enabled="true" />
                                <check name="ATH-div-0-unchk-local" enabled="true" />
                                <check name="ATH-div-0-unchk-param" enabled="true" />
                                <check name="ATH-div-0" enabled="true" />
                                <check name="ATH-inc-bool" enabled="true" />
                                <check name="ATH-malloc-overrun" enabled="true" />
                                <check name="ATH-neg-check-nonneg" enabled="true" />
                                <check name="ATH-neg-check-pos" enabled="true" />
                                <check name="ATH-new-overrun" enabled="true" />
                                <check name="ATH-overflow-cast" enabled="false" />
                                <check name="ATH-overflow" enabled="true" />
                                <check name="ATH-shift-bounds" enabled="true" />
                                <check name="ATH-shift-neg" enabled="true" />
                                <check name="ATH-sizeof-by-sizeof" enabled="true" />
                            </group>
                            <group enabled="true" name="CAST">
                                <check name="CAST-old-style" enabled="false" />
                            </group>
                            <group enabled="true" name="CATCH">
                                <check name="CATCH-object-slicing" enabled="true" />
                                <check name="CATCH-xtor-bad-member" enabled="false" />
                            </group>
                            <group enabled="true" name="COMMA">
                                <check name="COMMA-overload" enabled="false" />
                            </group>
                            <group enabled="true" name="COMMENT">
                                <check name="COMMENT-nested" enabled="true" />
                            </group>
                            <group enabled="true" name="CONST">
                                <check name="CONST-member-ret" enabled="true" />
                            </group>
                            <group enabled="true" name="COP">
                                <check name="COP-alloc-ctor" enabled="false" />
                                <check name="COP-assign-op-ret" enabled="true" />
                                <check name="COP-assign-op-self" enabled="true" />
                                <check name="COP-assign-op" enabled="true" />
                                <check name="COP-copy-ctor" enabled="true" />
                                <check name="COP-dealloc-dtor" enabled="false" />
                                <check name="COP-dtor-throw" enabled="true" />
                                <check name="COP-dtor" enabled="true" />
                                <check name="COP-init-order" enabled="true" />
                                <check name="COP-init-uninit" enabled="true" />
                                <check name="COP-member-uninit" enabled="true" />
                            </group>
                            <group enabled="true" name="CPU">
                                <check name="CPU-ctor-call-virt" enabled="true" />
                                <check name="CPU-ctor-implicit" enabled="false" />
                                <check name="CPU-delete-throw" enabled="true" />
                                <check name="CPU-delete-void" enabled="true" />
                                <check name="CPU-dtor-call-virt" enabled="true" />
                                <check name="CPU-malloc-class" enabled="true" />
                                <check name="CPU-nonvirt-dtor" enabled="true" />
                                <check name="CPU-return-ref-to-class-data" enabled="true" />
                            </group>
                            <group enabled="true" name="DECL">
                                <check name="DECL-implicit-int" enabled="false" />
                            </group>
                            <group enabled="true" name="DEFINE">
                                <check name="DEFINE-hash-multiple" enabled="true" />
                            </group>
                            <group enabled="true" name="ENUM">
                                <check name="ENUM-bounds" enabled="false" />
                            </group>
                            <group enabled="true" name="EXP">
                                <check name="EXP-cond-assign" enabled="true" />
                                <check name="EXP-dangling-else" enabled="true" />
                                <check name="EXP-loop-exit" enabled="true" />
                                <check name="EXP-main-ret-int" enabled="false" />
                                <check name="EXP-null-stmt" enabled="false" />
                                <check name="EXP-stray-semicolon" enabled="false" />
                            </group>
                            <group enabled="true" name="EXPR">
                                <check name="EXPR-const-overflow" enabled="true" />
                            </group>
                            <group enabled="true" name="FPT">
                                <check name="FPT-cmp-null" enabled="true" />
                                <check name="FPT-literal" enabled="false" />
                                <check name="FPT-misuse" enabled="true" />
                            </group>
                            <group enabled="true" name="FUNC">
                                <check name="FUNC-implicit-decl" enabled="false" />
                                <check name="FUNC-unprototyped-all" enabled="false" />
                                <check name="FUNC-unprototyped-used" enabled="true" />
                            </group>
                            <group enabled="true" name="INCLUDE">
                                <check name="INCLUDE-c-file" enabled="false" />
                            </group>
                            <group enabled="true" name="INT">
                                <check name="INT-use-signed-as-unsigned-pos" enabled="false" />
                                <check name="INT-use-signed-as-unsigned" enabled="true" />
                            </group>
                            <group enabled="true" name="ITR">
                                <check name="ITR-end-cmp-aft" enabled="true" />
                                <check name="ITR-end-cmp-bef" enabled="true" />
                                <check name="ITR-invalidated" enabled="true" />
                                <check name="ITR-mismatch-alg" enabled="false" />
                                <check name="ITR-store" enabled="false" />
                                <check name="ITR-uninit" enabled="true" />
                            </group>
                            <group enabled="true" name="LIB">
                                <check name="LIB-bsearch-overrun-pos" enabled="false" />
                                <check name="LIB-bsearch-overrun" enabled="false" />
                                <check name="LIB-fn-unsafe" enabled="false" />
                                <check name="LIB-fread-overrun-pos" enabled="false" />
                                <check name="LIB-fread-overrun" enabled="true" />
                                <check name="LIB-memchr-overrun-pos" enabled="false" />
                                <check name="LIB-memchr-overrun" enabled="true" />
                                <check name="LIB-memcpy-overrun-pos" enabled="false" />
                                <check name="LIB-memcpy-overrun" enabled="true" />
                                <check name="LIB-memset-overrun-pos" enabled="false" />
                                <check name="LIB-memset-overrun" enabled="true" />
                                <check name="LIB-putenv" enabled="false" />
                                <check name="LIB-qsort-overrun-pos" enabled="false" />
                                <check name="LIB-qsort-overrun" enabled="false" />
                                <check name="LIB-return-const" enabled="true" />
                                <check name="LIB-return-error" enabled="true" />
                                <check name="LIB-return-leak" enabled="true" />
                                <check name="LIB-return-neg" enabled="true" />
                                <check name="LIB-return-null" enabled="true" />
                                <check name="LIB-sprintf-overrun" enabled="false" />
                                <check name="LIB-std-sort-overrun-pos" enabled="false" />
                                <check name="LIB-std-sort-overrun" enabled="true" />
                                <check name="LIB-strcat-overrun-pos" enabled="false" />
                                <check name="LIB-strcat-overrun" enabled="true" />
                                <check name="LIB-strcpy-overrun-pos" enabled="false" />
                                <check name="LIB-strcpy-overrun" enabled="true" />
                                <check name="LIB-strncat-overrun-pos" enabled="false" />
                                <check name="LIB-strncat-overrun" enabled="true" />
                                <check name="LIB-strncmp-overrun-pos" enabled="false" />
                                <check name="LIB-strncmp-overrun" enabled="true" />
                                <check name="LIB-strncpy-overrun-pos" enabled="false" />
                                <check name="LIB-strncpy-overrun" enabled="true" />
                            </group>
                            <group enabled="true" name="LOGIC">
                                <check name="LOGIC-overload" enabled="false" />
                            </group>
                            <group enabled="true" name="MEM">
                                <check name="MEM-delete-array-op" enabled="true" />
                                <check name="MEM-delete-op" enabled="true" />
                                <check name="MEM-double-free-alias" enabled="true" />
                                <check name="MEM-double-free-some" enabled="true" />
                                <check name="MEM-double-free" enabled="true" />
                                <check name="MEM-free-field" enabled="true" />
                                <check name="MEM-free-fptr" enabled="true" />
                                <check name="MEM-free-no-alloc-struct" enabled="false" />
                                <check name="MEM-free-no-alloc" enabled="false" />
                                <check name="MEM-free-no-use" enabled="true" />
                                <check name="MEM-free-op" enabled="true" />
                                <check name="MEM-free-struct-field" enabled="true" />
                                <check name="MEM-free-variable-alias" enabled="true" />
                                <check name="MEM-free-variable" enabled="true" />
                                <check name="MEM-leak-alias" enabled="true" />
                                <check name="MEM-leak" enabled="false" />
                                <check name="MEM-malloc-arith" enabled="false" />
                                <check name="MEM-malloc-diff-type" enabled="true" />
                                <check name="MEM-malloc-sizeof-ptr" enabled="true" />
                                <check name="MEM-malloc-sizeof" enabled="true" />
                                <check name="MEM-malloc-strlen" enabled="false" />
                                <check name="MEM-realloc-diff-type" enabled="true" />
                                <check name="MEM-return-free" enabled="true" />
                                <check name="MEM-return-no-assign" enabled="true" />
                                <check name="MEM-stack-global-field" enabled="true" />
                                <check name="MEM-stack-global" enabled="true" />
                                <check name="MEM-stack-param-ref" enabled="true" />
                                <check name="MEM-stack-param" enabled="true" />
                                <check name="MEM-stack-pos" enabled="true" />
                                <check name="MEM-stack-ref" enabled="true" />
                                <check name="MEM-stack" enabled="true" />
                                <check name="MEM-use-free-all" enabled="true" />
                                <check name="MEM-use-free-some" enabled="true" />
                            </group>
                            <group enabled="true" name="PTR">
                                <check name="PTR-arith-field" enabled="true" />
                                <check name="PTR-arith-stack" enabled="true" />
                                <check name="PTR-arith-var" enabled="true" />
                                <check name="PTR-cmp-str-lit" enabled="true" />
                                <check name="PTR-null-assign-fun-pos" enabled="false" />
                                <check name="PTR-null-assign-pos" enabled="false" />
                                <check name="PTR-null-assign" enabled="true" />
                                <check name="PTR-null-cmp-aft" enabled="true" />
                                <check name="PTR-null-cmp-bef-fun" enabled="true" />
                                <check name="PTR-null-cmp-bef" enabled="true" />
                                <check name="PTR-null-fun-pos" enabled="true" />
                                <check name="PTR-null-literal-pos" enabled="false" />
                                <check name="PTR-overload" enabled="false" />
                                <check name="PTR-singleton-arith-pos" enabled="false" />
                                <check name="PTR-singleton-arith" enabled="true" />
                                <check name="PTR-unchk-param-some" enabled="true" />
                                <check name="PTR-unchk-param" enabled="false" />
                                <check name="PTR-uninit-pos" enabled="false" />
                                <check name="PTR-uninit" enabled="true" />
                            </group>
                            <group enabled="true" name="RED">
                                <check name="RED-alloc-zero-bytes" enabled="false" />
                                <check name="RED-case-reach" enabled="false" />
                                <check name="RED-cmp-always" enabled="false" />
                                <check name="RED-cmp-never" enabled="false" />
                                <check name="RED-cond-always" enabled="false" />
                                <check name="RED-cond-const-assign" enabled="true" />
                                <check name="RED-cond-const-expr" enabled="false" />
                                <check name="RED-cond-const" enabled="false" />
                                <check name="RED-cond-never" enabled="false" />
                                <check name="RED-dead" enabled="true" />
                                <check name="RED-expr" enabled="false" />
                                <check name="RED-func-no-effect" enabled="false" />
                                <check name="RED-local-hides-global" enabled="true" />
                                <check name="RED-local-hides-local" enabled="false" />
                                <check name="RED-local-hides-member" enabled="false" />
                                <check name="RED-local-hides-param" enabled="true" />
                                <check name="RED-no-effect" enabled="false" />
                                <check name="RED-self-assign" enabled="true" />
                                <check name="RED-unused-assign" enabled="true" />
                                <check name="RED-unused-param" enabled="false" />
                                <check name="RED-unused-return-val" enabled="false" />
                                <check name="RED-unused-val" enabled="false" />
                                <check name="RED-unused-var-all" enabled="true" />
                            </group>
                            <group enabled="true" name="RESOURCE">
                                <check name="RESOURCE-deref-file" enabled="false" />
                                <check name="RESOURCE-double-close" enabled="true" />
                                <check name="RESOURCE-file-no-close-all" enabled="true" />
                                <check name="RESOURCE-file-pos-neg" enabled="false" />
                                <check name="RESOURCE-file-use-after-close" enabled="true" />
                                <check name="RESOURCE-implicit-deref-file" enabled="false" />
                                <check name="RESOURCE-write-ronly-file" enabled="true" />
                            </group>
                            <group enabled="true" name="SIZEOF">
                                <check name="SIZEOF-side-effect" enabled="true" />
                            </group>
                            <group enabled="true" name="SPC">
                                <check name="SPC-order" enabled="true" />
                                <check name="SPC-uninit-arr-all" enabled="false" />
                                <check name="SPC-uninit-struct-field-heap" enabled="true" />
                                <check name="SPC-uninit-struct-field" enabled="false" />
                                <check name="SPC-uninit-struct" enabled="true" />
                                <check name="SPC-uninit-var-all" enabled="true" />
                                <check name="SPC-uninit-var-some" enabled="true" />
                                <check name="SPC-volatile-reads" enabled="false" />
                                <check name="SPC-volatile-writes" enabled="false" />
                            </group>
                            <group enabled="true" name="STRUCT">
                                <check name="STRUCT-signed-bit" enabled="false" />
                            </group>
                            <group enabled="true" name="SWITCH">
                                <check name="SWITCH-fall-through" enabled="true" />
                            </group>
                            <group enabled="true" name="THROW">
                                <check name="THROW-empty" enabled="false" />
                                <check name="THROW-main" enabled="false" />
                                <check name="THROW-null" enabled="true" />
                                <check name="THROW-ptr" enabled="true" />
                                <check name="THROW-static" enabled="true" />
                                <check name="THROW-unhandled" enabled="true" />
                            </group>
                            <group enabled="true" name="UNION">
                                <check name="UNION-overlap-assign" enabled="true" />
                                <check name="UNION-type-punning" enabled="true" />
                            </group>
                        </package>
                        <package name="CERT" enabled="false">
                            <group enabled="true" name="CERT-EXP">
                                <check name="CERT-EXP19-C" enabled="true" />
                            </group>
                            <group enabled="true" name="CERT-FIO">
                                <check name="CERT-FIO37-C" enabled="true" />
                                <check name="CERT-FIO38-C" enabled="true" />
                            </group>
                            <group enabled="true" name="CERT-SIG">
                                <check name="CERT-SIG31-C" enabled="true" />
                            </group>
                        </package>
                        <package name="SECURITY" enabled="false">
                            <group enabled="true" name="SEC-BUFFER">
                                <check name="SEC-BUFFER-memory-leak-alias" enabled="true" />
                                <check name="SEC-BUFFER-memory-leak" enabled="false" />
                                <check name="SEC-BUFFER-memset-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-memset-overrun" enabled="true" />
                                <check name="SEC-BUFFER-qsort-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-qsort-overrun" enabled="true" />
                                <check name="SEC-BUFFER-sprintf-overrun" enabled="true" />
                                <check name="SEC-BUFFER-std-sort-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-std-sort-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strcat-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strcat-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strcpy-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strcpy-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strncat-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strncat-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strncmp-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strncmp-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strncpy-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strncpy-overrun" enabled="true" />
                                <check name="SEC-BUFFER-tainted-alloc-size" enabled="true" />
                                <check name="SEC-BUFFER-tainted-copy-length" enabled="true" />
                                <check name="SEC-BUFFER-tainted-copy" enabled="true" />
                                <check name="SEC-BUFFER-tainted-index" enabled="true" />
                                <check name="SEC-BUFFER-tainted-offset" enabled="true" />
                                <check name="SEC-BUFFER-use-after-free-all" enabled="true" />
                                <check name="SEC-BUFFER-use-after-free-some" enabled="true" />
                            </group>
                            <group enabled="true" name="SEC-DIV-0">
                                <check name="SEC-DIV-0-compare-after" enabled="true" />
                                <check name="SEC-DIV-0-compare-before" enabled="true" />
                                <check name="SEC-DIV-0-tainted" enabled="true" />
                            </group>
                            <group enabled="true" name="SEC-FILEOP">
                                <check name="SEC-FILEOP-open-no-close" enabled="true" />
                                <check name="SEC-FILEOP-path-traversal" enabled="false" />
                                <check name="SEC-FILEOP-use-after-close" enabled="true" />
                            </group>
                            <group enabled="true" name="SEC-INJECTION">
                                <check name="SEC-INJECTION-sql" enabled="false" />
                                <check name="SEC-INJECTION-xpath" enabled="false" />
                            </group>
                            <group enabled="true" name="SEC-LOOP">
                                <check name="SEC-LOOP-tainted-bound" enabled="true" />
                            </group>
                            <group enabled="true" name="SEC-NULL">
                                <check name="SEC-NULL-assignment-fun-pos" enabled="false" />
                                <check name="SEC-NULL-assignment" enabled="true" />
                                <check name="SEC-NULL-cmp-aft" enabled="true" />
                                <check name="SEC-NULL-cmp-bef-fun" enabled="true" />
                                <check name="SEC-NULL-cmp-bef" enabled="true" />
                                <check name="SEC-NULL-literal-pos" enabled="false" />
                            </group>
                            <group enabled="true" name="SEC-STRING">
                                <check name="SEC-STRING-format-string" enabled="true" />
                                <check name="SEC-STRING-hard-coded-credentials" enabled="false" />
                            </group>
                        </package>
                        <package name="MISRAC2004" enabled="false">
                            <group enabled="true" name="MISRAC2004-1">
                                <check name="MISRAC2004-1.1" enabled="true" />
                                <check name="MISRAC2004-1.2_a" enabled="true" />
                                <check name="MISRAC2004-1.2_b" enabled="true" />
                                <check name="MISRAC2004-1.2_c" enabled="true" />
                                <check name="MISRAC2004-1.2_d" enabled="true" />
                                <check name="MISRAC2004-1.2_e" enabled="true" />
                                <check name="MISRAC2004-1.2_f" enabled="true" />
                                <check name="MISRAC2004-1.2_g" enabled="true" />
                                <check name="MISRAC2004-1.2_h" enabled="true" />
                                <check name="MISRAC2004-1.2_i" enabled="true" />
                                <check name="MISRAC2004-1.2_j" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-2">
                                <check name="MISRAC2004-2.1" enabled="true" />
                                <check name="MISRAC2004-2.2" enabled="true" />
                                <check name="MISRAC2004-2.3" enabled="true" />
                                <check name="MISRAC2004-2.4" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2004-5">
                                <check name="MISRAC2004-5.2" enabled="true" />
                                <check name="MISRAC2004-5.3" enabled="true" />
                                <check name="MISRAC2004-5.4" enabled="true" />
                                <check name="MISRAC2004-5.5" enabled="false" />
                                <check name="MISRAC2004-5.6" enabled="false" />
                                <check name="MISRAC2004-5.7" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2004-6">
                                <check name="MISRAC2004-6.1" enabled="true" />
                                <check name="MISRAC2004-6.2" enabled="true" />
                                <check name="MISRAC2004-6.3" enabled="false" />
                                <check name="MISRAC2004-6.4" enabled="true" />
                                <check name="MISRAC2004-6.5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-7">
                                <check name="MISRAC2004-7.1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-8">
                                <check name="MISRAC2004-8.1" enabled="true" />
                                <check name="MISRAC2004-8.2" enabled="true" />
                                <check name="MISRAC2004-8.3" enabled="true" />
                                <check name="MISRAC2004-8.5_a" enabled="true" />
                                <check name="MISRAC2004-8.5_b" enabled="true" />
                                <check name="MISRAC2004-8.6" enabled="true" />
                                <check name="MISRAC2004-8.7" enabled="true" />
                                <check name="MISRAC2004-8.8_a" enabled="true" />
                                <check name="MISRAC2004-8.8_b" enabled="true" />
                                <check name="MISRAC2004-8.12" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-8 10">
                                <check name="MISRAC2004-8.10" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-9">
                                <check name="MISRAC2004-9.1_a" enabled="true" />
                                <check name="MISRAC2004-9.1_b" enabled="true" />
                                <check name="MISRAC2004-9.1_c" enabled="true" />
                                <check name="MISRAC2004-9.2" enabled="true" />
                                <check name="MISRAC2004-9.3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-10">
                                <check name="MISRAC2004-10.1_a" enabled="true" />
                                <check name="MISRAC2004-10.1_b" enabled="true" />
                                <check name="MISRAC2004-10.1_c" enabled="true" />
                                <check name="MISRAC2004-10.1_d" enabled="true" />
                                <check name="MISRAC2004-10.2_a" enabled="true" />
                                <check name="MISRAC2004-10.2_b" enabled="true" />
                                <check name="MISRAC2004-10.2_c" enabled="true" />
                                <check name="MISRAC2004-10.2_d" enabled="true" />
                                <check name="MISRAC2004-10.3" enabled="true" />
                                <check name="MISRAC2004-10.4" enabled="true" />
                                <check name="MISRAC2004-10.5" enabled="true" />
                                <check name="MISRAC2004-10.6" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-11">
                                <check name="MISRAC2004-11.1" enabled="true" />
                                <check name="MISRAC2004-11.3" enabled="false" />
                                <check name="MISRAC2004-11.4" enabled="false" />
                                <check name="MISRAC2004-11.5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-12">
                                <check name="MISRAC2004-12.1" enabled="false" />
                                <check name="MISRAC2004-12.2_a" enabled="true" />
                                <check name="MISRAC2004-12.2_b" enabled="true" />
                                <check name="MISRAC2004-12.2_c" enabled="true" />
                                <check name="MISRAC2004-12.3" enabled="true" />
                                <check name="MISRAC2004-12.4" enabled="true" />
                                <check name="MISRAC2004-12.5" enabled="true" />
                                <check name="MISRAC2004-12.6_a" enabled="false" />
                                <check name="MISRAC2004-12.6_b" enabled="false" />
                                <check name="MISRAC2004-12.7" enabled="true" />
                                <check name="MISRAC2004-12.8" enabled="true" />
                                <check name="MISRAC2004-12.9" enabled="true" />
                                <check name="MISRAC2004-12.10" enabled="true" />
                                <check name="MISRAC2004-12.11" enabled="false" />
                                <check name="MISRAC2004-12.12_a" enabled="true" />
                                <check name="MISRAC2004-12.12_b" enabled="true" />
                                <check name="MISRAC2004-12.13" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2004-13">
                                <check name="MISRAC2004-13.1" enabled="true" />
                                <check name="MISRAC2004-13.2_a" enabled="false" />
                                <check name="MISRAC2004-13.2_b" enabled="false" />
                                <check name="MISRAC2004-13.2_c" enabled="false" />
                                <check name="MISRAC2004-13.2_d" enabled="false" />
                                <check name="MISRAC2004-13.2_e" enabled="false" />
                                <check name="MISRAC2004-13.3" enabled="true" />
                                <check name="MISRAC2004-13.4" enabled="true" />
                                <check name="MISRAC2004-13.5" enabled="true" />
                                <check name="MISRAC2004-13.6" enabled="true" />
                                <check name="MISRAC2004-13.7_a" enabled="true" />
                                <check name="MISRAC2004-13.7_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-14">
                                <check name="MISRAC2004-14.1" enabled="true" />
                                <check name="MISRAC2004-14.2" enabled="true" />
                                <check name="MISRAC2004-14.3" enabled="true" />
                                <check name="MISRAC2004-14.4" enabled="true" />
                                <check name="MISRAC2004-14.5" enabled="true" />
                                <check name="MISRAC2004-14.6" enabled="true" />
                                <check name="MISRAC2004-14.7" enabled="true" />
                                <check name="MISRAC2004-14.8_a" enabled="true" />
                                <check name="MISRAC2004-14.8_b" enabled="true" />
                                <check name="MISRAC2004-14.8_c" enabled="true" />
                                <check name="MISRAC2004-14.8_d" enabled="true" />
                                <check name="MISRAC2004-14.9" enabled="true" />
                                <check name="MISRAC2004-14.10" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-15">
                                <check name="MISRAC2004-15.0" enabled="true" />
                                <check name="MISRAC2004-15.1" enabled="true" />
                                <check name="MISRAC2004-15.2" enabled="true" />
                                <check name="MISRAC2004-15.3" enabled="true" />
                                <check name="MISRAC2004-15.4" enabled="true" />
                                <check name="MISRAC2004-15.5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-16">
                                <check name="MISRAC2004-16.1" enabled="true" />
                                <check name="MISRAC2004-16.2_a" enabled="true" />
                                <check name="MISRAC2004-16.2_b" enabled="true" />
                                <check name="MISRAC2004-16.3" enabled="true" />
                                <check name="MISRAC2004-16.4" enabled="true" />
                                <check name="MISRAC2004-16.5" enabled="true" />
                                <check name="MISRAC2004-16.7" enabled="true" />
                                <check name="MISRAC2004-16.8" enabled="true" />
                                <check name="MISRAC2004-16.9" enabled="true" />
                                <check name="MISRAC2004-16.10" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-17">
                                <check name="MISRAC2004-17.1_a" enabled="true" />
                                <check name="MISRAC2004-17.1_b" enabled="true" />
                                <check name="MISRAC2004-17.1_c" enabled="true" />
                                <check name="MISRAC2004-17.2" enabled="true" />
                                <check name="MISRAC2004-17.3" enabled="true" />
                                <check name="MISRAC2004-17.4_a" enabled="true" />
                                <check name="MISRAC2004-17.4_b" enabled="true" />
                                <check name="MISRAC2004-17.5" enabled="true" />
                                <check name="MISRAC2004-17.6_a" enabled="true" />
                                <check name="MISRAC2004-17.6_b" enabled="true" />
                                <check name="MISRAC2004-17.6_c" enabled="true" />
                                <check name="MISRAC2004-17.6_d" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-18">
                                <check name="MISRAC2004-18.1" enabled="true" />
                                <check name="MISRAC2004-18.2" enabled="true" />
                                <check name="MISRAC2004-18.4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-19">
                                <check name="MISRAC2004-19.1" enabled="false" />
                                <check name="MISRAC2004-19.2" enabled="false" />
                                <check name="MISRAC2004-19.4" enabled="true" />
                                <check name="MISRAC2004-19.5" enabled="true" />
                                <check name="MISRAC2004-19.6" enabled="true" />
                                <check name="MISRAC2004-19.7" enabled="false" />
                                <check name="MISRAC2004-19.10" enabled="true" />
                                <check name="MISRAC2004-19.12" enabled="true" />
                                <check name="MISRAC2004-19.13" enabled="false" />
                                <check name="MISRAC2004-19.15" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-20">
                                <check name="MISRAC2004-20.1" enabled="true" />
                                <check name="MISRAC2004-20.2" enabled="true" />
                                <check name="MISRAC2004-20.3_a" enabled="true" />
                                <check name="MISRAC2004-20.3_b" enabled="true" />
                                <check name="MISRAC2004-20.3_c" enabled="true" />
                                <check name="MISRAC2004-20.3_d" enabled="true" />
                                <check name="MISRAC2004-20.3_e" enabled="true" />
                                <check name="MISRAC2004-20.3_f" enabled="true" />
                                <check name="MISRAC2004-20.3_g" enabled="true" />
                                <check name="MISRAC2004-20.3_h" enabled="true" />
                                <check name="MISRAC2004-20.3_i" enabled="true" />
                                <check name="MISRAC2004-20.4" enabled="true" />
                                <check name="MISRAC2004-20.5" enabled="true" />
                                <check name="MISRAC2004-20.6" enabled="true" />
                                <check name="MISRAC2004-20.7" enabled="true" />
                                <check name="MISRAC2004-20.8" enabled="true" />
                                <check name="MISRAC2004-20.9" enabled="true" />
                                <check name="MISRAC2004-20.10" enabled="true" />
                                <check name="MISRAC2004-20.11" enabled="true" />
                                <check name="MISRAC2004-20.12" enabled="true" />
                            </group>
                        </package>
                        <package name="MISRAC2012" enabled="false">
                            <group enabled="true" name="MISRAC2012-Dir-4">
                                <check name="MISRAC2012-Dir-4.3" enabled="true" />
                                <check name="MISRAC2012-Dir-4.4" enabled="false" />
                                <check name="MISRAC2012-Dir-4.5" enabled="false" />
                                <check name="MISRAC2012-Dir-4.6_a" enabled="false" />
                                <check name="MISRAC2012-Dir-4.6_b" enabled="false" />
                                <check name="MISRAC2012-Dir-4.7_a" enabled="false" />
                                <check name="MISRAC2012-Dir-4.7_b" enabled="false" />
                                <check name="MISRAC2012-Dir-4.7_c" enabled="false" />
                                <check name="MISRAC2012-Dir-4.8" enabled="false" />
                                <check name="MISRAC2012-Dir-4.9" enabled="false" />
                                <check name="MISRAC2012-Dir-4.10" enabled="true" />
                                <check name="MISRAC2012-Dir-4.11_a" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_b" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_c" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_d" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_e" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_f" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_g" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_h" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_i" enabled="false" />
                                <check name="MISRAC2012-Dir-4.12" enabled="false" />
                                <check name="MISRAC2012-Dir-4.13_b" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_c" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_d" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_e" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_f" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_g" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_h" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-1">
                                <check name="MISRAC2012-Rule-1.3_a" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_b" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_c" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_d" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_e" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_f" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_g" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_h" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_i" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_j" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_k" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_m" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_n" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_o" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_p" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_q" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_r" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_s" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_t" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_u" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_v" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_w" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-2">
                                <check name="MISRAC2012-Rule-2.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-2.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-2.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-2.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-2.2_c" enabled="true" />
                                <check name="MISRAC2012-Rule-2.3" enabled="false" />
                                <check name="MISRAC2012-Rule-2.4" enabled="false" />
                                <check name="MISRAC2012-Rule-2.5" enabled="false" />
                                <check name="MISRAC2012-Rule-2.6" enabled="false" />
                                <check name="MISRAC2012-Rule-2.7" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-3">
                                <check name="MISRAC2012-Rule-3.1" enabled="true" />
                                <check name="MISRAC2012-Rule-3.2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-5">
                                <check name="MISRAC2012-Rule-5.1" enabled="true" />
                                <check name="MISRAC2012-Rule-5.2_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-5.2_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-5.3_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-5.3_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-5.4_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-5.4_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-5.5_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-5.5_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-5.6" enabled="true" />
                                <check name="MISRAC2012-Rule-5.7" enabled="true" />
                                <check name="MISRAC2012-Rule-5.8" enabled="true" />
                                <check name="MISRAC2012-Rule-5.9" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-6">
                                <check name="MISRAC2012-Rule-6.1" enabled="true" />
                                <check name="MISRAC2012-Rule-6.2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-7">
                                <check name="MISRAC2012-Rule-7.1" enabled="true" />
                                <check name="MISRAC2012-Rule-7.2" enabled="true" />
                                <check name="MISRAC2012-Rule-7.3" enabled="true" />
                                <check name="MISRAC2012-Rule-7.4_a" enabled="true" />
                                <check name="MISRAC2012-Rule-7.4_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-8">
                                <check name="MISRAC2012-Rule-8.1" enabled="true" />
                                <check name="MISRAC2012-Rule-8.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-8.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-8.3_b" enabled="true" />
                                <check name="MISRAC2012-Rule-8.4" enabled="true" />
                                <check name="MISRAC2012-Rule-8.5_a" enabled="true" />
                                <check name="MISRAC2012-Rule-8.5_b" enabled="true" />
                                <check name="MISRAC2012-Rule-8.7" enabled="false" />
                                <check name="MISRAC2012-Rule-8.9_a" enabled="false" />
                                <check name="MISRAC2012-Rule-8.9_b" enabled="false" />
                                <check name="MISRAC2012-Rule-8.10" enabled="true" />
                                <check name="MISRAC2012-Rule-8.11" enabled="false" />
                                <check name="MISRAC2012-Rule-8.12" enabled="true" />
                                <check name="MISRAC2012-Rule-8.13" enabled="false" />
                                <check name="MISRAC2012-Rule-8.14" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-9">
                                <check name="MISRAC2012-Rule-9.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_c" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_d" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_e" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_f" enabled="true" />
                                <check name="MISRAC2012-Rule-9.2" enabled="true" />
                                <check name="MISRAC2012-Rule-9.3" enabled="true" />
                                <check name="MISRAC2012-Rule-9.4" enabled="true" />
                                <check name="MISRAC2012-Rule-9.5_a" enabled="true" />
                                <check name="MISRAC2012-Rule-9.5_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-10">
                                <check name="MISRAC2012-Rule-10.1_R2" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R3" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R4" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R5" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R6" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R7" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R8" enabled="true" />
                                <check name="MISRAC2012-Rule-10.2" enabled="true" />
                                <check name="MISRAC2012-Rule-10.3" enabled="true" />
                                <check name="MISRAC2012-Rule-10.4_a" enabled="true" />
                                <check name="MISRAC2012-Rule-10.4_b" enabled="true" />
                                <check name="MISRAC2012-Rule-10.5" enabled="false" />
                                <check name="MISRAC2012-Rule-10.6" enabled="true" />
                                <check name="MISRAC2012-Rule-10.7" enabled="true" />
                                <check name="MISRAC2012-Rule-10.8" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-11">
                                <check name="MISRAC2012-Rule-11.1" enabled="true" />
                                <check name="MISRAC2012-Rule-11.2" enabled="true" />
                                <check name="MISRAC2012-Rule-11.3" enabled="true" />
                                <check name="MISRAC2012-Rule-11.4" enabled="false" />
                                <check name="MISRAC2012-Rule-11.5" enabled="false" />
                                <check name="MISRAC2012-Rule-11.6" enabled="true" />
                                <check name="MISRAC2012-Rule-11.7" enabled="true" />
                                <check name="MISRAC2012-Rule-11.8" enabled="true" />
                                <check name="MISRAC2012-Rule-11.9" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-12">
                                <check name="MISRAC2012-Rule-12.1" enabled="false" />
                                <check name="MISRAC2012-Rule-12.2" enabled="true" />
                                <check name="MISRAC2012-Rule-12.3" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-13">
                                <check name="MISRAC2012-Rule-13.1" enabled="true" />
                                <check name="MISRAC2012-Rule-13.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-13.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-13.2_c" enabled="true" />
                                <check name="MISRAC2012-Rule-13.3" enabled="false" />
                                <check name="MISRAC2012-Rule-13.4_a" enabled="false" />
                                <check name="MISRAC2012-Rule-13.4_b" enabled="false" />
                                <check name="MISRAC2012-Rule-13.5" enabled="true" />
                                <check name="MISRAC2012-Rule-13.6" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-14">
                                <check name="MISRAC2012-Rule-14.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-14.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-14.2" enabled="true" />
                                <check name="MISRAC2012-Rule-14.3_a" enabled="true" />
                                <check name="MISRAC2012-Rule-14.3_b" enabled="true" />
                                <check name="MISRAC2012-Rule-14.4_a" enabled="true" />
                                <check name="MISRAC2012-Rule-14.4_b" enabled="true" />
                                <check name="MISRAC2012-Rule-14.4_c" enabled="true" />
                                <check name="MISRAC2012-Rule-14.4_d" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-15">
                                <check name="MISRAC2012-Rule-15.1" enabled="false" />
                                <check name="MISRAC2012-Rule-15.2" enabled="true" />
                                <check name="MISRAC2012-Rule-15.3" enabled="true" />
                                <check name="MISRAC2012-Rule-15.4" enabled="false" />
                                <check name="MISRAC2012-Rule-15.5" enabled="false" />
                                <check name="MISRAC2012-Rule-15.6_a" enabled="true" />
                                <check name="MISRAC2012-Rule-15.6_b" enabled="true" />
                                <check name="MISRAC2012-Rule-15.6_c" enabled="true" />
                                <check name="MISRAC2012-Rule-15.6_d" enabled="true" />
                                <check name="MISRAC2012-Rule-15.6_e" enabled="true" />
                                <check name="MISRAC2012-Rule-15.7" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-16">
                                <check name="MISRAC2012-Rule-16.1" enabled="true" />
                                <check name="MISRAC2012-Rule-16.2" enabled="true" />
                                <check name="MISRAC2012-Rule-16.3" enabled="true" />
                                <check name="MISRAC2012-Rule-16.4" enabled="true" />
                                <check name="MISRAC2012-Rule-16.5" enabled="true" />
                                <check name="MISRAC2012-Rule-16.6" enabled="true" />
                                <check name="MISRAC2012-Rule-16.7" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-17">
                                <check name="MISRAC2012-Rule-17.1" enabled="true" />
                                <check name="MISRAC2012-Rule-17.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-17.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-17.3" enabled="true" />
                                <check name="MISRAC2012-Rule-17.4" enabled="true" />
                                <check name="MISRAC2012-Rule-17.5" enabled="false" />
                                <check name="MISRAC2012-Rule-17.6" enabled="true" />
                                <check name="MISRAC2012-Rule-17.7" enabled="true" />
                                <check name="MISRAC2012-Rule-17.8" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-18">
                                <check name="MISRAC2012-Rule-18.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-18.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-18.1_c" enabled="true" />
                                <check name="MISRAC2012-Rule-18.1_d" enabled="true" />
                                <check name="MISRAC2012-Rule-18.2" enabled="true" />
                                <check name="MISRAC2012-Rule-18.3" enabled="true" />
                                <check name="MISRAC2012-Rule-18.4" enabled="true" />
                                <check name="MISRAC2012-Rule-18.5" enabled="false" />
                                <check name="MISRAC2012-Rule-18.6_a" enabled="true" />
                                <check name="MISRAC2012-Rule-18.6_b" enabled="true" />
                                <check name="MISRAC2012-Rule-18.6_c" enabled="true" />
                                <check name="MISRAC2012-Rule-18.6_d" enabled="true" />
                                <check name="MISRAC2012-Rule-18.7" enabled="true" />
                                <check name="MISRAC2012-Rule-18.8" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-19">
                                <check name="MISRAC2012-Rule-19.1" enabled="true" />
                                <check name="MISRAC2012-Rule-19.2" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-20">
                                <check name="MISRAC2012-Rule-20.1" enabled="false" />
                                <check name="MISRAC2012-Rule-20.2" enabled="true" />
                                <check name="MISRAC2012-Rule-20.4_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-20.4_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-20.5" enabled="false" />
                                <check name="MISRAC2012-Rule-20.7" enabled="true" />
                                <check name="MISRAC2012-Rule-20.10" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-21">
                                <check name="MISRAC2012-Rule-21.1" enabled="true" />
                                <check name="MISRAC2012-Rule-21.2" enabled="true" />
                                <check name="MISRAC2012-Rule-21.3" enabled="true" />
                                <check name="MISRAC2012-Rule-21.4" enabled="true" />
                                <check name="MISRAC2012-Rule-21.5" enabled="true" />
                                <check name="MISRAC2012-Rule-21.6" enabled="true" />
                                <check name="MISRAC2012-Rule-21.7" enabled="true" />
                                <check name="MISRAC2012-Rule-21.8" enabled="true" />
                                <check name="MISRAC2012-Rule-21.9" enabled="true" />
                                <check name="MISRAC2012-Rule-21.10" enabled="true" />
                                <check name="MISRAC2012-Rule-21.11" enabled="true" />
                                <check name="MISRAC2012-Rule-21.12_a" enabled="false" />
                                <check name="MISRAC2012-Rule-21.12_b" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-22">
                                <check name="MISRAC2012-Rule-22.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-22.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-22.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-22.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-22.2_c" enabled="true" />
                                <check name="MISRAC2012-Rule-22.3" enabled="true" />
                                <check name="MISRAC2012-Rule-22.4" enabled="true" />
                                <check name="MISRAC2012-Rule-22.5_a" enabled="true" />
                                <check name="MISRAC2012-Rule-22.5_b" enabled="true" />
                                <check name="MISRAC2012-Rule-22.6" enabled="true" />
                            </group>
                        </package>
                        <package name="MISRAC++2008" enabled="false">
                            <group enabled="true" name="MISRAC++2008-0-1">
                                <check name="MISRAC++2008-0-1-1" enabled="true" />
                                <check name="MISRAC++2008-0-1-2_a" enabled="true" />
                                <check name="MISRAC++2008-0-1-2_b" enabled="true" />
                                <check name="MISRAC++2008-0-1-2_c" enabled="true" />
                                <check name="MISRAC++2008-0-1-3" enabled="true" />
                                <check name="MISRAC++2008-0-1-4_a" enabled="true" />
                                <check name="MISRAC++2008-0-1-4_b" enabled="true" />
                                <check name="MISRAC++2008-0-1-6" enabled="true" />
                                <check name="MISRAC++2008-0-1-7" enabled="true" />
                                <check name="MISRAC++2008-0-1-8" enabled="false" />
                                <check name="MISRAC++2008-0-1-9" enabled="true" />
                                <check name="MISRAC++2008-0-1-11" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-0-2">
                                <check name="MISRAC++2008-0-2-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-0-3">
                                <check name="MISRAC++2008-0-3-2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-2-7">
                                <check name="MISRAC++2008-2-7-1" enabled="true" />
                                <check name="MISRAC++2008-2-7-2" enabled="true" />
                                <check name="MISRAC++2008-2-7-3" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-2-10">
                                <check name="MISRAC++2008-2-10-1" enabled="true" />
                                <check name="MISRAC++2008-2-10-2" enabled="true" />
                                <check name="MISRAC++2008-2-10-3" enabled="true" />
                                <check name="MISRAC++2008-2-10-4" enabled="true" />
                                <check name="MISRAC++2008-2-10-5" enabled="false" />
                                <check name="MISRAC++2008-2-10-6" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-2-13">
                                <check name="MISRAC++2008-2-13-2" enabled="true" />
                                <check name="MISRAC++2008-2-13-3" enabled="true" />
                                <check name="MISRAC++2008-2-13-4_a" enabled="true" />
                                <check name="MISRAC++2008-2-13-4_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-3-1">
                                <check name="MISRAC++2008-3-1-1" enabled="true" />
                                <check name="MISRAC++2008-3-1-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-3-9">
                                <check name="MISRAC++2008-3-9-2" enabled="false" />
                                <check name="MISRAC++2008-3-9-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-4-5">
                                <check name="MISRAC++2008-4-5-1" enabled="true" />
                                <check name="MISRAC++2008-4-5-2" enabled="true" />
                                <check name="MISRAC++2008-4-5-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-0">
                                <check name="MISRAC++2008-5-0-1_a" enabled="true" />
                                <check name="MISRAC++2008-5-0-1_b" enabled="true" />
                                <check name="MISRAC++2008-5-0-1_c" enabled="true" />
                                <check name="MISRAC++2008-5-0-2" enabled="false" />
                                <check name="MISRAC++2008-5-0-3" enabled="true" />
                                <check name="MISRAC++2008-5-0-4" enabled="true" />
                                <check name="MISRAC++2008-5-0-5" enabled="true" />
                                <check name="MISRAC++2008-5-0-6" enabled="true" />
                                <check name="MISRAC++2008-5-0-7" enabled="true" />
                                <check name="MISRAC++2008-5-0-8" enabled="true" />
                                <check name="MISRAC++2008-5-0-9" enabled="true" />
                                <check name="MISRAC++2008-5-0-10" enabled="true" />
                                <check name="MISRAC++2008-5-0-13_a" enabled="true" />
                                <check name="MISRAC++2008-5-0-13_b" enabled="true" />
                                <check name="MISRAC++2008-5-0-13_c" enabled="true" />
                                <check name="MISRAC++2008-5-0-13_d" enabled="true" />
                                <check name="MISRAC++2008-5-0-14" enabled="true" />
                                <check name="MISRAC++2008-5-0-15_a" enabled="true" />
                                <check name="MISRAC++2008-5-0-15_b" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_a" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_b" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_c" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_d" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_e" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_f" enabled="true" />
                                <check name="MISRAC++2008-5-0-19" enabled="true" />
                                <check name="MISRAC++2008-5-0-21" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-2">
                                <check name="MISRAC++2008-5-2-4" enabled="true" />
                                <check name="MISRAC++2008-5-2-5" enabled="true" />
                                <check name="MISRAC++2008-5-2-6" enabled="true" />
                                <check name="MISRAC++2008-5-2-7" enabled="true" />
                                <check name="MISRAC++2008-5-2-9" enabled="false" />
                                <check name="MISRAC++2008-5-2-10" enabled="false" />
                                <check name="MISRAC++2008-5-2-11_a" enabled="true" />
                                <check name="MISRAC++2008-5-2-11_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-3">
                                <check name="MISRAC++2008-5-3-1" enabled="true" />
                                <check name="MISRAC++2008-5-3-2_a" enabled="true" />
                                <check name="MISRAC++2008-5-3-2_b" enabled="true" />
                                <check name="MISRAC++2008-5-3-3" enabled="true" />
                                <check name="MISRAC++2008-5-3-4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-8">
                                <check name="MISRAC++2008-5-8-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-14">
                                <check name="MISRAC++2008-5-14-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-18">
                                <check name="MISRAC++2008-5-18-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-19">
                                <check name="MISRAC++2008-5-19-1" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-2">
                                <check name="MISRAC++2008-6-2-1" enabled="true" />
                                <check name="MISRAC++2008-6-2-2" enabled="true" />
                                <check name="MISRAC++2008-6-2-3" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-3">
                                <check name="MISRAC++2008-6-3-1_a" enabled="true" />
                                <check name="MISRAC++2008-6-3-1_b" enabled="true" />
                                <check name="MISRAC++2008-6-3-1_c" enabled="true" />
                                <check name="MISRAC++2008-6-3-1_d" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-4">
                                <check name="MISRAC++2008-6-4-1" enabled="true" />
                                <check name="MISRAC++2008-6-4-2" enabled="true" />
                                <check name="MISRAC++2008-6-4-3" enabled="true" />
                                <check name="MISRAC++2008-6-4-4" enabled="true" />
                                <check name="MISRAC++2008-6-4-5" enabled="true" />
                                <check name="MISRAC++2008-6-4-6" enabled="true" />
                                <check name="MISRAC++2008-6-4-7" enabled="true" />
                                <check name="MISRAC++2008-6-4-8" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-5">
                                <check name="MISRAC++2008-6-5-1_a" enabled="true" />
                                <check name="MISRAC++2008-6-5-2" enabled="true" />
                                <check name="MISRAC++2008-6-5-3" enabled="true" />
                                <check name="MISRAC++2008-6-5-4" enabled="true" />
                                <check name="MISRAC++2008-6-5-6" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-6">
                                <check name="MISRAC++2008-6-6-1" enabled="true" />
                                <check name="MISRAC++2008-6-6-2" enabled="true" />
                                <check name="MISRAC++2008-6-6-4" enabled="true" />
                                <check name="MISRAC++2008-6-6-5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-1">
                                <check name="MISRAC++2008-7-1-1" enabled="true" />
                                <check name="MISRAC++2008-7-1-2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-2">
                                <check name="MISRAC++2008-7-2-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-4">
                                <check name="MISRAC++2008-7-4-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-5">
                                <check name="MISRAC++2008-7-5-1_a" enabled="true" />
                                <check name="MISRAC++2008-7-5-1_b" enabled="true" />
                                <check name="MISRAC++2008-7-5-2_a" enabled="true" />
                                <check name="MISRAC++2008-7-5-2_b" enabled="true" />
                                <check name="MISRAC++2008-7-5-2_c" enabled="true" />
                                <check name="MISRAC++2008-7-5-2_d" enabled="true" />
                                <check name="MISRAC++2008-7-5-4_a" enabled="false" />
                                <check name="MISRAC++2008-7-5-4_b" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-8-0">
                                <check name="MISRAC++2008-8-0-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-8-4">
                                <check name="MISRAC++2008-8-4-1" enabled="true" />
                                <check name="MISRAC++2008-8-4-3" enabled="true" />
                                <check name="MISRAC++2008-8-4-4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-8-5">
                                <check name="MISRAC++2008-8-5-1_a" enabled="true" />
                                <check name="MISRAC++2008-8-5-1_b" enabled="true" />
                                <check name="MISRAC++2008-8-5-1_c" enabled="true" />
                                <check name="MISRAC++2008-8-5-2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-9-3">
                                <check name="MISRAC++2008-9-3-1" enabled="true" />
                                <check name="MISRAC++2008-9-3-2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-9-5">
                                <check name="MISRAC++2008-9-5-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-9-6">
                                <check name="MISRAC++2008-9-6-2" enabled="true" />
                                <check name="MISRAC++2008-9-6-3" enabled="true" />
                                <check name="MISRAC++2008-9-6-4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-12-1">
                                <check name="MISRAC++2008-12-1-1_a" enabled="true" />
                                <check name="MISRAC++2008-12-1-1_b" enabled="true" />
                                <check name="MISRAC++2008-12-1-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-0">
                                <check name="MISRAC++2008-15-0-2" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-1">
                                <check name="MISRAC++2008-15-1-2" enabled="true" />
                                <check name="MISRAC++2008-15-1-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-3">
                                <check name="MISRAC++2008-15-3-1" enabled="true" />
                                <check name="MISRAC++2008-15-3-2" enabled="false" />
                                <check name="MISRAC++2008-15-3-3" enabled="true" />
                                <check name="MISRAC++2008-15-3-4" enabled="true" />
                                <check name="MISRAC++2008-15-3-5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-5">
                                <check name="MISRAC++2008-15-5-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-16-0">
                                <check name="MISRAC++2008-16-0-3" enabled="true" />
                                <check name="MISRAC++2008-16-0-4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-16-2">
                                <check name="MISRAC++2008-16-2-2" enabled="true" />
                                <check name="MISRAC++2008-16-2-3" enabled="true" />
                                <check name="MISRAC++2008-16-2-4" enabled="true" />
                                <check name="MISRAC++2008-16-2-5" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-16-3">
                                <check name="MISRAC++2008-16-3-1" enabled="true" />
                                <check name="MISRAC++2008-16-3-2" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-17-0">
                                <check name="MISRAC++2008-17-0-1" enabled="true" />
                                <check name="MISRAC++2008-17-0-3" enabled="true" />
                                <check name="MISRAC++2008-17-0-5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-0">
                                <check name="MISRAC++2008-18-0-1" enabled="true" />
                                <check name="MISRAC++2008-18-0-2" enabled="true" />
                                <check name="MISRAC++2008-18-0-3" enabled="true" />
                                <check name="MISRAC++2008-18-0-4" enabled="true" />
                                <check name="MISRAC++2008-18-0-5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-2">
                                <check name="MISRAC++2008-18-2-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-4">
                                <check name="MISRAC++2008-18-4-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-7">
                                <check name="MISRAC++2008-18-7-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-19-3">
                                <check name="MISRAC++2008-19-3-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-27-0">
                                <check name="MISRAC++2008-27-0-1" enabled="true" />
                            </group>
                        </package>
                    </checks_tree>
                </cstat_settings>
            </data>
        </settings>
        <settings>
            <name>RuntimeChecking</name>
            <archiveVersion>0</archiveVersion>
            <data>
                <version>2</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>GenRtcDebugHeap</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcEnableBoundsChecking</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcCheckPtrsNonInstrMem</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcTrackPointerBounds</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcCheckAccesses</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcGenerateEntries</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcNrTrackedPointers</name>
                    <state>1000</state>
                </option>
                <option>
                    <name>GenRtcIntOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIncUnsigned</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIntConversion</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcInclExplicit</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIntShiftOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcInclUnsignedShiftOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcUnhandledCase</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcDivByZero</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcEnable</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcCheckPtrsNonInstrFunc</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
    </configuration>
    <group>
        <name>airkiss</name>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\application\airkiss\airkiss.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\application\airkiss\lib_airkisscloud.a</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\application\airkiss\lib_rt_airkiss_algo.a</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\application\airkiss\libairkiss.a</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\application\airkiss\libairkiss_log.a</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\application\airkiss\prefix_libwxcloud.a</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\application\airkiss\wifi_airkiss.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\application\airkiss\wifi_airkiss.h</name>
        </file>
    </group>
    <group>
        <name>Ayla</name>
        <group>
            <name>Ayla_demo</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\ayla_demo\src\Ayla_cloud.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\ayla_demo\src\Ayla_demo_common.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\ayla_demo\src\Ayla_demo_conf.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\ayla_demo\src\Ayla_demo_ledevb.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\ayla_demo\src\Ayla_demo_ota.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\ayla_demo\src\Ayla_demo_sched.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\ayla_demo\src\Ayla_demo_stub.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\ayla_demo\src\Ayla_demo_wifi.c</name>
            </file>
        </group>
        <group>
            <name>libada</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\ada_conf.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\ada_err.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\al\ameba\ada_lock.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\al\ameba\ameba_conf.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\al\ameba\ameba_log.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\certs\ca_certs_der.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\client.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\client_auth.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\client_conf.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\client_ota.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\client_prop.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\al\ameba\client_task.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\conf_json.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\al\ameba\conf_table.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\text\custom.css.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\dnss.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\dnss_util.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\al\ameba\http_client.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\lan.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\log_page.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\notify.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\al\ameba\notify_task.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\oem.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\prop_mgr.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\prop_page.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\text\regtoken.html.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\sched.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\al\ameba\sched_conf.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\schedeval.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\al\ameba\server.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\server_mem.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\server_req.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\sprop.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\al\ameba\stubs.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libada\sys_conf.c</name>
            </file>
        </group>
        <group>
            <name>libadw</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libadw\adw_wifi_conf.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libadw\text\lock.gif.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libadw\text\refresh.gif.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libadw\wifi.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libadw\text\wifi.html.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libadw\text\wifi.js.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libadw\wifi_ameba.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libadw\wifi_page.c</name>
            </file>
        </group>
        <group>
            <name>libayla</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\arch\ameba\clock.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\clock_fmt.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\clock_sw.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\clock_utils.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\cmd_handle.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\conf.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\arch\ameba\conf_flash.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\crc.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\crc16.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\crc8.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\endian.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\format_mac.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\format_string.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\hostname_valid.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\http.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\ext\jsmn\jsmn.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\jsmn_get.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\jsmn_iterate.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\json_format_string.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\log.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\log_cmd.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\log_conf.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\log_io.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\lookup_by_name.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\lookup_by_val.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\arch\ameba\malloc.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\parse_argv.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\parse_date.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\parse_hex.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\parse_mac.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\parse_url.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\timer.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\uri_arg_allowed_map.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\uri_decode.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\uri_encode.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\utf8.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\xml.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\xml_decode.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libayla\xml_encode.c</name>
            </file>
        </group>
        <group>
            <name>libnet</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libnet\ameba\ipaddr_fmt.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libnet\ameba\net_mbuf.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libnet\ameba\net_realtek.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libnet\ameba\ssl.c</name>
            </file>
            <configuration>
                <name>Debug</name>
            </configuration>
        </group>
        <configuration>
            <name>Debug</name>
        </configuration>
    </group>
    <group>
        <name>Ayla_ameba</name>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\ayla_demo\src\Ayla_demo_ledkey.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\application\ayla\libayla\libadw\wifi_ameba_drv.c</name>
        </file>
        <configuration>
            <name>Debug</name>
        </configuration>
    </group>
    <group>
        <name>cmsis</name>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8711b\cmsis\device\app_start.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8711b\fwlib\ram_lib\startup.c</name>
        </file>
    </group>
    <group>
        <name>console</name>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\api\at_cmd\atcmd_cloud.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\api\at_cmd\atcmd_lwip.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\api\at_cmd\atcmd_sys.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\api\at_cmd\atcmd_wifi.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\api\at_cmd\log_service.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8711b\app\monitor\ram\low_level_io.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8711b\app\monitor\ram\monitor.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8711b\app\monitor\ram\rtl_consol.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8711b\app\monitor\ram\rtl_trace.c</name>
        </file>
    </group>
    <group>
        <name>lib</name>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8711b\misc\bsp\lib\common\IAR\lib_andlink.a</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8711b\misc\bsp\lib\common\IAR\lib_http.a</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8711b\misc\bsp\lib\common\IAR\lib_mdns.a</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8711b\misc\bsp\lib\common\IAR\lib_p2p.a</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8711b\misc\bsp\lib\common\IAR\lib_platform.a</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8711b\misc\bsp\lib\common\IAR\lib_rtlstd.a</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8711b\misc\bsp\lib\common\IAR\lib_websocket.a</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8711b\misc\bsp\lib\common\IAR\lib_wlan.a</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8711b\misc\bsp\lib\common\IAR\lib_wlan_mp.a</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8711b\misc\bsp\lib\common\IAR\lib_wps.a</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8711b\misc\bsp\lib\common\IAR\lib_xmodem.a</name>
        </file>
    </group>
    <group>
        <name>network</name>
        <group>
            <name>api</name>
            <group>
                <name>wifi</name>
                <group>
                    <name>rtw_wpa_supplicant</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\component\common\api\wifi\rtw_wpa_supplicant\wpa_supplicant\wifi_eap_config.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\component\common\api\wifi\rtw_wpa_supplicant\wpa_supplicant\wifi_p2p_config.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\component\common\api\wifi\rtw_wpa_supplicant\wpa_supplicant\wifi_wps_config.c</name>
                    </file>
                </group>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\api\wifi\wifi_conf.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\api\wifi\wifi_ind.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\api\wifi\wifi_promisc.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\api\wifi\wifi_simple_config.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\api\wifi\wifi_util.c</name>
                </file>
            </group>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\api\lwip_netconf.c</name>
            </file>
        </group>
        <group>
            <name>app</name>
            <group>
                <name>mqtt</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\application\mqtt\MQTTClient\MQTTClient.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\application\mqtt\MQTTPacket\MQTTConnectClient.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\application\mqtt\MQTTPacket\MQTTConnectServer.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\application\mqtt\MQTTPacket\MQTTDeserializePublish.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\application\mqtt\MQTTPacket\MQTTFormat.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\application\mqtt\MQTTClient\MQTTFreertos.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\application\mqtt\MQTTPacket\MQTTPacket.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\application\mqtt\MQTTPacket\MQTTSerializePublish.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\application\mqtt\MQTTPacket\MQTTSubscribeClient.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\application\mqtt\MQTTPacket\MQTTSubscribeServer.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\application\mqtt\MQTTPacket\MQTTUnsubscribeClient.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\application\mqtt\MQTTPacket\MQTTUnsubscribeServer.c</name>
                </file>
            </group>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\api\network\src\ping_test.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\utilities\ssl_client.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\utilities\tcptest.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\api\network\src\wlan_network.c</name>
            </file>
        </group>
        <group>
            <name>coap</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\network\coap\sn_coap_ameba_port.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\network\coap\sn_coap_builder.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\network\coap\sn_coap_header_check.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\network\coap\sn_coap_parser.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\network\coap\sn_coap_protocol.c</name>
            </file>
        </group>
        <group>
            <name>googlenest</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\google\google_tls.c</name>
            </file>
        </group>
        <group>
            <name>http</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\network\httpc\httpc_tls.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\network\httpd\httpd_tls.c</name>
            </file>
        </group>
        <group>
            <name>lwip</name>
            <group>
                <name>api</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\api\api_lib.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\api\api_msg.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\api\err.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\api\netbuf.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\api\netdb.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\api\netifapi.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\api\sockets.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\api\tcpip.c</name>
                </file>
            </group>
            <group>
                <name>core</name>
                <group>
                    <name>ipv4</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\ipv4\autoip.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\ipv4\icmp.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\ipv4\igmp.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\ipv4\inet.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\ipv4\inet_chksum.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\ipv4\ip.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\ipv4\ip_addr.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\ipv4\ip_frag.c</name>
                    </file>
                </group>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\def.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\dhcp.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\dns.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\init.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\lwip_timers.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\mem.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\memp.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\netif.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\pbuf.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\raw.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\stats.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\sys.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\tcp.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\tcp_in.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\tcp_out.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\core\udp.c</name>
                </file>
            </group>
            <group>
                <name>netif</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\src\netif\etharp.c</name>
                </file>
            </group>
            <group>
                <name>port</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\port\realtek\freertos\ethernetif.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\drivers\wlan\realtek\src\osdep\lwip_intf.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\lwip\lwip_v1.4.1\port\realtek\freertos\sys_arch.c</name>
                </file>
            </group>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\network\dhcp\dhcps.c</name>
            </file>
        </group>
        <group>
            <name>mdns</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\network\mDNS\mDNSPlatform.c</name>
            </file>
        </group>
        <group>
            <name>polarssl</name>
            <group>
                <name>polarssl</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\aes.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\aesni.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\arc4.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\asn1parse.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\asn1write.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\base64.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\bignum.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\blowfish.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\camellia.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\ccm.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\certs.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\cipher.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\cipher_wrap.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\ctr_drbg.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\debug.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\des.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\dhm.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\ecdh.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\ecdsa.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\ecp.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\ecp_curves.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\ecp_ram.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\entropy.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\entropy_poll.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\error.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\gcm.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\havege.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\hmac_drbg.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\md.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\md2.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\md4.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\md5.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\md_wrap.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\memory_buffer_alloc.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\net.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\oid.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\padlock.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\pbkdf2.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\pem.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\pk.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\pk_wrap.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\pkcs11.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\pkcs12.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\pkcs5.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\pkparse.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\pkwrite.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\platform.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\ripemd160.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\rsa.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\sha1.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\sha256.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\sha512.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\ssl_cache.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\ssl_ciphersuites.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\ssl_cli.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\ssl_srv.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\ssl_tls.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\threading.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\timing.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\version.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\version_features.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\x509.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\x509_create.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\x509_crl.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\x509_crt.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\x509_csr.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\x509write_crt.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\x509write_csr.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\polarssl-1.3.8\library\xtea.c</name>
                </file>
            </group>
            <group>
                <name>ssl_ram_map</name>
            </group>
        </group>
        <group>
            <name>websocket</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\network\websocket\wsclient_tls.c</name>
            </file>
        </group>
    </group>
    <group>
        <name>os</name>
        <group>
            <name>freertos</name>
            <group>
                <name>portable</name>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\os\freertos\freertos_v8.1.2\Source\portable\MemMang\heap_5.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\os\freertos\freertos_v8.1.2\Source\portable\IAR\ARM_CM4F\port.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\..\component\os\freertos\freertos_v8.1.2\Source\portable\IAR\ARM_CM4F\portasm.s</name>
                </file>
            </group>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\os\freertos\cmsis_os.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\os\freertos\freertos_v8.1.2\Source\croutine.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\os\freertos\freertos_v8.1.2\Source\event_groups.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\os\freertos\freertos_service.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\os\freertos\freertos_v8.1.2\Source\list.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\os\freertos\freertos_v8.1.2\Source\queue.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\os\freertos\freertos_v8.1.2\Source\tasks.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\os\freertos\freertos_v8.1.2\Source\timers.c</name>
            </file>
        </group>
        <group>
            <name>osdep</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\os\os_dep\device_lock.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\os\os_dep\osdep_service.c</name>
            </file>
        </group>
    </group>
    <group>
        <name>peripheral</name>
        <group>
            <name>api</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8711b\analogin_api.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8711b\dma_api.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8711b\efuse_api.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8711b\flash_api.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8711b\gpio_api.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8711b\gpio_irq_api.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8711b\i2c_api.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8711b\i2s_api.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8711b\nfc_api.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8711b\pinmap.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8711b\pinmap_common.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8711b\port_api.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8711b\pwmout_api.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8711b\rtc_api.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8711b\serial_api.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8711b\sleep.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8711b\spi_api.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8711b\sys_api.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8711b\timer_api.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8711b\us_ticker.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8711b\us_ticker_api.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8711b\wait_api.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\mbed\targets\hal\rtl8711b\wdt_api.c</name>
            </file>
        </group>
        <group>
            <name>rtl8710b</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8711b\fwlib\ram_lib\rtl8710b_dsleepcfg.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8711b\fwlib\ram_lib\rtl8710b_dstandbycfg.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8711b\fwlib\ram_lib\rtl8710b_intfcfg.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8711b\misc\rtl8710b_ota.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8711b\fwlib\ram_lib\rtl8710b_pinmapcfg.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\soc\realtek\8711b\fwlib\ram_lib\rtl8710b_sleepcfg.c</name>
            </file>
        </group>
        <group>
            <name>wlan</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\drivers\wlan\realtek\src\core\option\rtw_opt_power_by_rate.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\drivers\wlan\realtek\src\core\option\rtw_opt_power_limit.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\drivers\wlan\realtek\src\core\option\rtw_opt_skbuf.c</name>
            </file>
        </group>
    </group>
    <group>
        <name>TLS</name>
        <group>
            <name>ssl_ram_map</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\ssl_ram_map\rom\rom_ssl_ram_map.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\ssl_ram_map\ssl_ram_map.c</name>
            </file>
        </group>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\aes.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\aesni.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\arc4.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\asn1parse.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\asn1write.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\base64.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\bignum.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\blowfish.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\camellia.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\ccm.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\certs.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\cipher.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\cipher_wrap.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\cmac.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\ctr_drbg.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\debug.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\des.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\dhm.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\ecdh.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\ecdsa.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\ecjpake.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\ecp.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\ecp_curves.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\entropy.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\entropy_poll.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\error.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\gcm.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\havege.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\hmac_drbg.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\md.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\md2.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\md4.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\md5.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\md_wrap.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\memory_buffer_alloc.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\net_sockets.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\oid.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\padlock.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\pem.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\pk.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\pk_wrap.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\pkcs11.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\pkcs12.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\pkcs5.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\pkparse.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\pkwrite.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\platform.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\ripemd160.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\rsa.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\sha1.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\sha256.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\sha512.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\ssl_cache.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\ssl_ciphersuites.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\ssl_cli.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\ssl_cookie.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\ssl_srv.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\ssl_ticket.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\ssl_tls.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\threading.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\timing.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\version.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\version_features.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\x509.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\x509_create.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\x509_crl.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\x509_crt.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\x509_csr.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\x509write_crt.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\x509write_csr.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\network\ssl\mbedtls-2.4.0\library\xtea.c</name>
        </file>
        <configuration>
            <name>Debug</name>
        </configuration>
    </group>
    <group>
        <name>user</name>
        <file>
            <name>$PROJ_DIR$\..\src\main.c</name>
        </file>
    </group>
    <group>
        <name>utilities</name>
        <group>
            <name>example</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\bcast\example_bcast.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\coap\example_coap.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\eap\example_eap.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\example_entry.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\get_beacon_frame\example_get_beacon_frame.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\googlenest\example_google.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\high_load_memory_use\example_high_load_memory_use.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\http_client\example_http_client.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\http_download\example_http_download.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\httpc\example_httpc.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\httpd\example_httpd.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\inic_gspi\example_inic_gspi.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\mcast\example_mcast.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\mdns\example_mdns.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\mqtt\example_mqtt.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\nonblock_connect\example_nonblock_connect.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\ota_http\example_ota_http.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\rarp\example_rarp.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\sntp_showtime\example_sntp_showtime.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\socket_select\example_socket_select.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\ssl_download\example_ssl_download.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\ssl_server\example_ssl_server.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\tcp_keepalive\example_tcp_keepalive.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\uart_atcmd\example_uart_atcmd.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\uart_firmware_update\example_uart_update.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\wifi_mac_monitor\example_wifi_mac_monitor.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\wifi_roaming\example_wifi_roaming.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\wlan_fast_connect\example_wlan_fast_connect.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\wlan_scenario\example_wlan_scenario.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\websocket\example_wsclient.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\example\xml\example_xml.c</name>
            </file>
        </group>
        <group>
            <name>wigadget</name>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\wigadget\cloud_link.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\wigadget\shtc1.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\..\component\common\application\wigadget\wigadget.c</name>
            </file>
        </group>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\utilities\cJSON.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\utilities\http_client.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\application\xmodem\uart_fw_update.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\utilities\uart_socket.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\utilities\webserver.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\..\component\common\utilities\xml.c</name>
        </file>
    </group>
</project>
